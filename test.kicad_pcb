File: test.kicad_pcb (KiCad board)
At the start: 2 copper layers, 43.2 x 43.2 mm, 3 parts

Commit message: update
Parts:
- removed ? (x2): , label
