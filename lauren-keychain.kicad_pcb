File: lauren-keychain.kicad_pcb (KiCad board)
At the start: 2 copper layers, 53.6 x 27.5 mm, 6 parts

Commit message: update lauren keychain
Other:
- board text added: "117th U.S. CONGRESS"
